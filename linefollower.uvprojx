# Keil uVision project linefollower.uvprojx, settings and files
target LineFollower (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: linefollower +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: .\app;.\bsp;.\config;.\vendor\Device\Include;.\vendor\CMSIS\Include;.\vendor\SPL\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\config\linefollower.sct
  group App
    ./app/: main.c line_estimator.c menu.c control.c robot.c zone_manager.c blackbox.c
  group Board
    ./bsp/: board.c buttons.c line_adc.c motor.c oled.c timebase.c log_storage.c log_serial.c
  group Startup
    ./startup/: startup_stm32f10x_md.s system_stm32f10x.c
  group SPL
    ./vendor/SPL/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
